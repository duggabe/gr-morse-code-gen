options:
  parameters:
    author: Barry Duggan
    description: Morse code generator
    generate_options: qt_gui
    id: MorseGen
    output_language: python
    title: Morse Code Generator
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: speed/1.2
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '300'
    step: '100'
    stop: '20000'
    value: '800'
  states: {}
- name: repeat
  id: variable
  parameters:
    value: '1200'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: baud*repeat
  states: {}
- name: speed
  id: variable
  parameters:
    value: '12'
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: freq
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: hw:CARD=Device,DEV=0
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: repeat
    type: byte
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nMorse code vector source\n\"\"\"\n\n#  epy_block_0.py\n#  revised 09/10/2019 - finish code table\n#  revised 09/11/2019 - test for bad character\n\nimport numpy as np\nfrom gnuradio import gr\n\nMorse = {\n  # codes from https://www.itu.int/rec/R-REC-M.1677-1-200910-I/en\n    \"A\": \"1,0,1,1,1\",\n    \"B\": \"1,1,1,0,1,0,1,0,1\",\n    \"C\": \"1,1,1,0,1,0,1,1,1,0,1\",\n    \"D\": \"1,1,1,0,1,0,1\",\n    \"E\": \"1\",\n    \"F\": \"1,0,1,0,1,1,1,0,1\",\n    \"G\": \"1,1,1,0,1,1,1,0,1\",\n    \"H\": \"1,0,1,0,1,0,1\",\n    \"I\": \"1,0,1\",\n    \"J\": \"1,0,1,1,1,0,1,1,1,0,1,1,1\",\n    \"K\": \"1,1,1,0,1,0,1,1,1\",\n    \"L\": \"1,0,1,1,1,0,1,0,1\",\n    \"M\": \"1,1,1,0,1,1,1\",\n    \"N\": \"1,1,1,0,1\",\n    \"O\": \"1,1,1,0,1,1,1,0,1,1,1\",\n    \"P\": \"1,0,1,1,1,0,1,1,1,0,1\",\n    \"Q\": \"1,1,1,0,1,1,1,0,1,0,1,1,1\",\n    \"R\": \"1,0,1,1,1,0,1\",\n    \"S\": \"1,0,1,0,1\",\n    \"T\": \"1,1,1\",\n    \"U\": \"1,0,1,0,1,1,1\",\n    \"V\": \"1,0,1,0,1,0,1,1,1\",\n    \"W\": \"1,0,1,1,1,0,1,1,1\",\n    \"X\": \"1,1,1,0,1,0,1,0,1,1,1\",\n    \"Y\": \"1,1,1,0,1,0,1,1,1,0,1,1,1\",\n    \"Z\": \"1,1,1,0,1,1,1,0,1,0,1\",\n    \" \": \"0\",            # space\n    \"1\": \"1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1\",\n    \"2\": \"1,0,1,0,1,1,1,0,1,1,1,0,1,1,1\",\n    \"3\": \"1,0,1,0,1,0,1,1,1,0,1,1,1\",\n    \"4\": \"1,0,1,0,1,0,1,0,1,1,1\",\n    \"5\": \"1,0,1,0,1,0,1,0,1\",\n    \"6\": \"1,1,1,0,1,0,1,0,1,0,1\",\n    \"7\": \"1,1,1,0,1,1,1,0,1,0,1,0,1\",\n    \"8\": \"1,1,1,0,1,1,1,0,1,1,1,0,1,0,1\",\n    \"9\": \"1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1\",\n    \"0\": \"1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1\",\n    \".\": \"1,0,1,1,1,0,1,0,1,1,1,0,1,0,1,1,1\",          # period\n    \",\": \"1,1,1,0,1,1,1,0,1,0,1,0,1,1,1,0,1,1,1\",      # comma\n    \":\": \"1,1,1,0,1,1,1,0,1,1,1,0,1,0,1,0,1\",          # colon\n    \"?\": \"1,0,1,0,1,1,1,0,1,1,1,0,1,0,1\",              # question\n    \"'\": \"1,0,1,1,1,0,1,1,1,0,1,1,1,0,1,1,1,0,1\",      # apostrophe\n    \"-\": \"1,1,1,0,1,0,1,0,1,0,1,0,1,1,1\",              # dash or minus\n    \"/\": \"1,1,1,0,1,0,1,0,1,1,1,0,1\",                  # slash\n    \"(\": \"1,1,1,0,1,0,1,1,1,0,1,1,1,0,1\",              # left parenthesis\n    \")\": \"1,1,1,0,1,0,1,1,1,0,1,1,1,0,1,0,1,1,1\",      # right parenthesis\n    \"\\\"\": \"1,0,1,1,1,0,1,0,1,0,1,1,1,0,1\",             # quote\n    \"=\": \"1,1,1,0,1,0,1,0,1,0,1,1,1\",                  # equals\n    \"+\": \"1,0,1,1,1,0,1,0,1,1,1,0,1\",                  # plus\n    \"@\": \"1,0,1,1,1,0,1,1,1,0,1,0,1,1,1,0,1\",          # at sign (@)\n  # these punctuation marks are not included in the ITU recommendation,\n  # but are found in https://en.wikipedia.org/wiki/Morse_code\n    \"!\": \"1,1,1,0,1,0,1,1,1,0,1,0,1,1,1,0,1,1,1\",      # exclamation point\n    \"&\": \"1,0,1,1,1,0,1,0,1,0,1\",                      # ampersand (also prosign for 'WAIT')\n    \";\": \"1,1,1,0,1,0,1,1,1,0,1,0,1,1,1,0,1\",          # semicolon\n    \"_\": \"1,0,1,0,1,1,1,0,1,1,1,0,1,0,1,1,1\",          # underscore\n    \"$\": \"1,0,1,0,1,0,1,1,1,0,1,0,1,0,1,1,1\"           # dollar sign\n      }\n\nclass mc_sync_block(gr.sync_block):\n    \"\"\"\n    reads input from sysin\n    generates a vector of Morse code bits\n    \"\"\"\n    def __init__(self):\n        gr.sync_block.__init__(self,\n            name = \"Morse code vector source\",\n            in_sig = None,\n            out_sig = [np.byte]\n        )\n\n    def work(self, input_items, output_items):\n        global Morse\n\n        in_text = input (\": \")\n        bit_stream = \"\"\n        for in0 in in_text:\n            # get next char\n            inChar = str (in0)\n            # convert to upper case\n            ch = inChar.upper()\n            # test for character in table\n            if (not(ch in Morse)):\n                # print (\"bad char\", ch)\n                ch = \"?\"        # replace bad character with a '?'\n            # build vector\n            _dots = str (Morse.get(ch))\n            # print (ch, _dots)\n            bit_stream += (_dots + \",0,0,0,\")    # letter space\n\n        bit_stream += \"0,0,0,0\"    # finish with word space\n        # print (bit_stream)\n\n        # get length of string\n        _len = len(bit_stream)\n        # num of elements = (length+1) / 2\n        _num_elem = int((_len+1) / 2)\n\n        # convert and store elements in output array\n        for x in range (_len):\n            y = int(x / 2)\n            if (bit_stream[x] == '1'):\n                output_items[0][y] = 1\n            elif (bit_stream[x] == '0'):\n                output_items[0][y] = 0\n            else:\n                continue    # skip commas\n\n        return (_num_elem)\n\n"
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    nconnections: '2'
    size: '4096'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '1.5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: (int)(48000/samp_rate)
    taps: ''
    type: fff
  states: {}
- name: single_pole_iir_filter_xx_0
  id: single_pole_iir_filter_xx
  parameters:
    alpha: '0.25'
    type: float
  states: {}

connections:
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0, '1']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_multiply_xx_0, '0', rational_resampler_xxx_0, '0']
- [blocks_repeat_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', single_pole_iir_filter_xx_0, '0']
- [epy_block_0, '0', blocks_repeat_0, '0']
- [rational_resampler_xxx_0, '0', audio_sink_0, '0']
- [single_pole_iir_filter_xx_0, '0', blocks_multiply_xx_0, '0']
- [single_pole_iir_filter_xx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
